#include <ctype.h>
#include <stdint.h>
#include <string.h>
#include "driver/i2c_master.h"
#include "esp_log.h"
#include "oled.h"

#define WIDTH 128
#define HEIGHT 64
#define PAGES (HEIGHT / 8)
#define OLED_TIMEOUT_MS 75
static i2c_master_dev_handle_t device;
static uint8_t frame[PAGES][WIDTH];
static uint8_t mostrado[PAGES][WIDTH];
static uint8_t paginas_enviadas;


static const uint8_t font5x7[][5] = {
    {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7F,0x14,0x7F,0x14},
    {0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x56,0x20,0x50},{0x00,0x08,0x07,0x03,0x00},
    {0x00,0x1C,0x22,0x41,0x00},{0x00,0x41,0x22,0x1C,0x00},{0x2A,0x1C,0x7F,0x1C,0x2A},{0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x80,0x70,0x30,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x00,0x60,0x60,0x00},{0x20,0x10,0x08,0x04,0x02},
    {0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},{0x72,0x49,0x49,0x49,0x46},{0x21,0x41,0x49,0x4D,0x33},
    {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x31},{0x41,0x21,0x11,0x09,0x07},
    {0x36,0x49,0x49,0x49,0x36},{0x46,0x49,0x49,0x29,0x1E},{0x00,0x00,0x14,0x00,0x00},{0x00,0x40,0x34,0x00,0x00},
    {0x00,0x08,0x14,0x22,0x41},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x59,0x09,0x06},
    {0x3E,0x41,0x5D,0x59,0x4E},{0x7C,0x12,0x11,0x12,0x7C},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x41,0x3E},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x41,0x51,0x73},
    {0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
    {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x1C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},{0x26,0x49,0x49,0x49,0x32},
    {0x03,0x01,0x7F,0x01,0x03},{0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
    {0x63,0x14,0x08,0x14,0x63},{0x03,0x04,0x78,0x04,0x03},{0x61,0x59,0x49,0x4D,0x43}
};

_Static_assert(sizeof(font5x7) / sizeof(font5x7[0]) == (90 - 32 + 1), "ASCII font must cover space to Z");

static void draw_text(unsigned y, const char *text)
{
    unsigned x = 1;
    while (*text && x + 5 <= WIDTH) {
        int c = toupper((unsigned char)*text++);
        if (c < 32 || c > 90) {
            c = '?';
        }
        for (unsigned col = 0; col < 5; ++col) {
            unsigned bits = (unsigned)font5x7[c - 32][col] << (y % 8);
            frame[y / 8][x + col] |= bits & 0xFF;
            if (y / 8 + 1 < PAGES) {
                frame[y / 8 + 1][x + col] |= bits >> 8;
            }
        }
        x += 6;
    }
}

esp_err_t oled_init(void)
{
    const i2c_master_bus_config_t config = {
        .i2c_port = I2C_NUM_0,
        .sda_io_num = GPIO_NUM_21,
        .scl_io_num = GPIO_NUM_22,
        .clk_source = I2C_CLK_SRC_DEFAULT,
        .glitch_ignore_cnt = 7,
        .flags.enable_internal_pullup = true,
    };
    i2c_master_bus_handle_t bus;
    esp_err_t result = i2c_new_master_bus(&config, &bus);
    if (result != ESP_OK) {
        return result;
    }

    uint8_t address = 0x3C;
    result = i2c_master_probe(bus, address, OLED_TIMEOUT_MS);
    if (result != ESP_OK) {
        address = 0x3D;
        result = i2c_master_probe(bus, address, OLED_TIMEOUT_MS);
    }
    if (result != ESP_OK) {
        i2c_del_master_bus(bus);
        return result;
    }

    const i2c_device_config_t oled = {
        .dev_addr_length = I2C_ADDR_BIT_LEN_7,
        .device_address = address,
        .scl_speed_hz = 100000,
    };
    result = i2c_master_bus_add_device(bus, &oled, &device);
    if (result == ESP_OK) {
        const uint8_t init[] = {
            0x00, 0xAE, 0xD5, 0x80, 0xA8, 0x3F, 0xD3, 0x00, 0x40,
            0x8D, 0x14, 0x20, 0x00, 0xA1, 0xC8, 0xDA, 0x12, 0x81, 0xCF,
            0xD9, 0xF1, 0xDB, 0x40, 0xA4, 0xA6, 0xAF
        };
        result = i2c_master_transmit(device, init, sizeof(init), OLED_TIMEOUT_MS);
        if (result != ESP_OK) {
            i2c_master_bus_rm_device(device);
            device = NULL;
        }
    }
    if (result != ESP_OK) {
        i2c_del_master_bus(bus);
        return result;
    }
    ESP_LOGI("OLED", "SSD1306 I2C 0x%02X inicializada", address);
    return ESP_OK;
}

esp_err_t oled_show(const oled_vista_t *vista)
{
    if (!device) {
        return ESP_ERR_INVALID_STATE;
    }
    memset(frame, 0, sizeof(frame));
    static const uint8_t posiciones[] = {0, 8, 22, 32, 42, 57};
    _Static_assert(sizeof(posiciones) == OLED_FILAS, "Una posicion por fila");
    memset(frame[2], 1U << 2, WIDTH);  // Separador en y=18.
    for (unsigned fila = 0; fila < OLED_FILAS; fila++) {
        draw_text(posiciones[fila], vista->texto[fila]);
    }

    uint8_t packet[WIDTH + 1] = {0x40};
    for (unsigned page = 0; page < PAGES; ++page) {
        uint8_t bit = 1U << page;
        if ((paginas_enviadas & bit) && memcmp(frame[page], mostrado[page], WIDTH) == 0) {
            continue;
        }
        const uint8_t range[] = {0x00, 0x21, 0, WIDTH - 1, 0x22, page, page};
        esp_err_t result = i2c_master_transmit(device, range, sizeof(range), OLED_TIMEOUT_MS);
        if (result != ESP_OK) {
            return result;
        }
        memcpy(packet + 1, frame[page], WIDTH);
        result = i2c_master_transmit(device, packet, sizeof(packet), OLED_TIMEOUT_MS);
        if (result != ESP_OK) {
            return result;
        }
        memcpy(mostrado[page], frame[page], WIDTH);
        paginas_enviadas |= bit;
    }
    return ESP_OK;
}
